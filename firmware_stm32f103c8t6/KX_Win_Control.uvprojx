# Keil uVision project KX_Win_Control.uvprojx, settings and files
target KX_Win_Control (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KX_Win_Control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\The_App;.\The_HAL;.\The_Mcal\Drive\adc;.\The_Mcal\Drive\iwdg;.\The_Mcal\Drive\SysTick;.\The_Mcal\Drive\Usart;.\The_Mcal\Drive\time;.\The_Driver\Libraies\STM32F10x_StdPeriph_Driver\inc;.\The_Driver\Libraies\STM32F10x_StdPeriph_Driver\src;.\The_Driver\Obj\Objects;.\The_Driver\Obj\Listings;.\The_Driver\Libraies\CMSIS\ARM;.\The_Driver\Libraies\CMSIS;.\THE_USER;.\The_Mcal\Drive\pwm;.\The_Mcal\Drive\led;.\The_HAL\Data_analysis;.\The_HAL\Roobt_leg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group The_App
    ./The_APP/: APP.c
  group The_HAL
    ./The_Mcal/Drive/SysTick/: system.c
    ./The_HAL/Data_analysis/: Data_analysis.c
    ./The_HAL/Roobt_leg/: Roobt_leg.c
  group The_Mcal
    ./The_Mcal/Drive/SysTick/: SysTick.c
    ./The_Mcal/Drive/Usart/: usart.c
    ./The_Mcal/Drive/time/: time.c
    ./The_Mcal/Drive/pwm/: pwm.c
  group The_Driver
    ./The_Driver/Libraies/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group The_Startup
    ./The_Driver/Libraies/CMSIS/: core_cm3.c stm32f10x.h stm32f10x_it.c system_stm32f10x.c system_stm32f10x.h
    ./The_Driver/Libraies/CMSIS/ARM/: startup_stm32f10x_md.s
  group The_User
    ./THE_USER/: main.c
